FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://q71l.cfg"
