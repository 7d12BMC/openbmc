RDEPENDS_${PN}-inventory_append_quanta-q71l = "webui-vue \
					       obmc-ikvm"
