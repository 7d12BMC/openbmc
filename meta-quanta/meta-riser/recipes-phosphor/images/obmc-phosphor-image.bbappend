OBMC_IMAGE_EXTRA_INSTALL_append_quanta-riser = " quanta-powerctrl"

# dts for riser includes snooping, so let's leverage that.
OBMC_IMAGE_EXTRA_INSTALL_append_quanta-riser = " phosphor-host-postd"

