KBRANCH ?= "dev-5.10"
LINUX_VERSION ?= "5.10.43"

SRCREV="035f3f03314d48ce43f36c57491bcf21e5b10b39"

require linux-aspeed.inc
